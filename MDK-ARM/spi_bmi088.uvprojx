# Keil uVision project spi_bmi088.uvprojx, settings and files
target spi_bmi088 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: spi_bmi088 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,BMI088_USE_SPI
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../Device/bmi088;../Device/bluetooth;../Device/vision;../Device/track;../Device/vofa;../mode;../task;../Application/algorithm;../Application/ins;../Application/gimbal;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c freertos.c can.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group BSP
    ../BSP/: bsp_spi.c bsp_uart.c bsp_uart6.c bsp_delay.c
    ../bsp/: bsp_laser.c bsp_can.c
  group device
    ../Device/bmi088/: bmi088.c
    ../Device/bluetooth/: bluetooth.c
    ../Device/vision/: vision.c
    ../Device/track/: track.c
    ../Device/vofa/: vofa.c
  group mode
    ../mode/: mode_control.c mode_stop.c mode_forward.c mode_backward.c mode_turn_left.c mode_turn_right.c mode_tracking.c mode_square_tracking.c mode_target_aim.c mode_gimbal.c
  group Task
    ../task/: task_control.c task1.c task2.c task3.c task4.c task5.c
  group Application
    ../Application/algorithm/: attitude_algorithm.c crc16.c adrc_eso.c lqr_controller.c balance_outer_loop.c balance_zero_bias_search.c
    ../Application/ins/: ins_task.c
    ../Application/gimbal/: gimbal_task.c chassis_serial_cmd.c
  group FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
